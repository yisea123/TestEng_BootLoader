# IAR project Project.ewp, settings and files
configuration Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\BootApp\inc; ..\BootDrv\inc; ..\BootOth\inc; ..\..\Libraries\CMSIS; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\modbus\ascii\; ..\modbus\include\; ..\modbus\modbus_port\; ..\modbus\rtu\; ..\modbus\tcp\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Boot.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\Libraries\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../Libraries/: stm32f10x_flash.icf
    ../../Libraries/CMSIS/: stm32f10x_it.c
  group BootApp
    ../BootApp/src/: BootApp_Cfg.c BootApp_Cfg_Debug.c BootApp_Cfg_FL0001A00.c BootApp_Cfg_FLT804A00.c BootApp_EreaseApp.c BootApp_ErrHdlr.c BootApp_HandleCmd.c BootApp_Init.c BootApp_IoFunctions.c BootApp_Jump2App.c BootApp_ProgramFlash.c BootApp_ReceiveData.c BootApp_Reset.c BootApp_StateMachine.c BootApp_ValidateApp.c BootDrv_Adapter.c main.c
  group BootDrv
    ../BootDrv/src/: AD7949.c AT24HC02C.c delay.c eep_m95160.c i2c.c init.c LTC2380.c LTC2620.c LTC2668.c MAX5478.c max7312.c spi.c
  group BootOth
    ../BootOth/src/: Boot_GetApp_Data.c check_error.c command.c main.c power_manage.c
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f10x.c
  group EWARMv5
    ../../Libraries/CMSIS/iar/: startup_stm32f10x_md.s
  group modbus
    ../modbus/: mb.c
  group modbus/ascii
    ../modbus/ascii/: mbascii.c mbascii.h
  group modbus/functions
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group modbus/include
    ../modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group modbus/modbus_port
    ../modbus/modbus_port/: port.h portCB.c portevent.c portserial.c porttimer.c
  group modbus/rtu
    ../modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group modbus/tcp
    ../modbus/tcp/: mbtcp.c mbtcp.h
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
