<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Boot</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>BootApp</name>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_Cfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_Cfg_Debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_Cfg_FL0001A00.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_Cfg_FLT804A00.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_EreaseApp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_ErrHdlr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_HandleCmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_Init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_IoFunctions.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_Jump2App.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_ProgramFlash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_ReceiveData.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_Reset.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_StateMachine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootApp_ValidateApp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\BootDrv_Adapter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootApp\src\main.c</name>
    </file>
  </group>
  <group>
    <name>BootDrv</name>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\AD7949.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\AT24HC02C.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\eep_m95160.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\LTC2380.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\LTC2620.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\LTC2668.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\MAX5478.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\max7312.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootDrv\src\spi.c</name>
    </file>
  </group>
  <group>
    <name>BootOth</name>
    <file>
      <name>$PROJ_DIR$\..\BootOth\src\Boot_GetApp_Data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootOth\src\check_error.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootOth\src\command.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootOth\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BootOth\src\power_manage.c</name>
    </file>
  </group>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\system_stm32f10x.c</name>
    </file>
  </group>
  <group>
    <name>EWARMv5</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\iar\startup_stm32f10x_md.s</name>
    </file>
  </group>
  <group>
    <name>modbus</name>
    <group>
      <name>ascii</name>
      <file>
        <name>$PROJ_DIR$\..\modbus\ascii\mbascii.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\ascii\mbascii.h</name>
      </file>
    </group>
    <group>
      <name>functions</name>
      <file>
        <name>$PROJ_DIR$\..\modbus\functions\mbfunccoils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\functions\mbfuncdiag.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\functions\mbfuncdisc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\functions\mbfuncholding.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\functions\mbfuncinput.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\functions\mbfuncother.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\functions\mbutils.c</name>
      </file>
    </group>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\modbus\include\mb.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\include\mbconfig.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\include\mbframe.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\include\mbfunc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\include\mbport.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\include\mbproto.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\include\mbutils.h</name>
      </file>
    </group>
    <group>
      <name>modbus_port</name>
      <file>
        <name>$PROJ_DIR$\..\modbus\modbus_port\port.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\modbus_port\portCB.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\modbus_port\portevent.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\modbus_port\portserial.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\modbus_port\porttimer.c</name>
      </file>
    </group>
    <group>
      <name>rtu</name>
      <file>
        <name>$PROJ_DIR$\..\modbus\rtu\mbcrc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\rtu\mbcrc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\rtu\mbrtu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\rtu\mbrtu.h</name>
      </file>
    </group>
    <group>
      <name>tcp</name>
      <file>
        <name>$PROJ_DIR$\..\modbus\tcp\mbtcp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\modbus\tcp\mbtcp.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\modbus\mb.c</name>
    </file>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\Libraries\stm32f10x_flash.icf</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\Libraries\CMSIS\stm32f10x_it.c</name>
  </file>
</project>


