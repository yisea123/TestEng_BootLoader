# IAR project Project.ewp, settings and files
configuration Burn_in_2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\DFB_inc; ..\..\Libraries\CMSIS; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\modbus\ascii\; ..\modbus\include\; ..\modbus\modbus_port\; ..\modbus\rtu\; ..\modbus\tcp\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DFB.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\Libraries\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../Libraries/: stm32f10x_flash.icf
    ../../Libraries/CMSIS/: stm32f10x_it.c
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f10x.c
  group EWARMv5
    ../../Libraries/CMSIS/iar/: startup_stm32f10x_md.s
  group modbus
    ../modbus/: mb.c
  group modbus/ascii
    ../modbus/ascii/: mbascii.c mbascii.h
  group modbus/functions
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group modbus/include
    ../modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group modbus/modbus_port
    ../modbus/modbus_port/: port.h portCB.c portevent.c portserial.c porttimer.c
  group modbus/rtu
    ../modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group modbus/tcp
    ../modbus/tcp/: mbtcp.c mbtcp.h
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../DFB_src/: AD7949.c App_cfg.c AT24HC02C.c Boot_GetApp_Data.c command.c delay.c init.c io_functions.c main.c spi.c
